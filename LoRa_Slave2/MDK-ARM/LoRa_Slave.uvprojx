# Keil uVision project LoRa_Slave.uvprojx, settings and files
target LoRa_Slave (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRa_Slave +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include;  ..\App\Base;  ..\App\Cjson;  ..\App\radio\inc;  ..\App\Task;  ..\App\Tea;  ..\App\Temperature;  ..\App\FAN;  ..\App\ParseData;  ..\App\AIR;  ..\App\Body;  ..\App\Light;  ..\App\SoilHumi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/Task
    ../App/Task/: stask.c stick.c stimer.c
  group Application/Radio
    ../App/radio/src/: sx1276.c sx1276_hal.c sx1276_timer.c sx1276_user.c sx1276-board.c
  group Application/Base
    ../App/Base/: base_key.c base_usart.c
  group Application/Cjson
    ../App/Cjson/: cJSON.c cJSON_Utils.c
  group Application/Tea
    ../App/Tea/: tea.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/Temperature
    ../App/Temperature/: Temperature.c
  group Application/FAN
    ../App/FAN/: fan.c
  group Application/ParseData
    ../App/ParseData/: getData.c
  group Application/SouiiHumi
    ../App/SoilHumi/: soilHumi.c
  group Application/Body
    ../App/Body/: body.c
  group Application/AIR
    ../App/AIR/: air.c
  group Application/Light
    ../App/Light/: light.c
software components: CMSIS:CORE 4.3.0
